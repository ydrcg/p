# Keil uVision project 串行通讯.uvproj, settings and files
target Target 1 (MCS-51)
  device: 89C52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: 串行通讯 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 串行通讯.c
